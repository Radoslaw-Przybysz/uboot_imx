## board/uavx/mx6uavx/Kconfig
```kconfig
if TARGET_MX6UAVX

config SYS_BOARD
	default "mx6uavx"

config SYS_VENDOR
	default "uavx"

config SYS_CONFIG_NAME
	default "mx6uavx"

endif
```
